# Repository seveibar/arduino-btshield

## KiCad design btshield.kicad_pcb

Parts:
C1: C; C_Disc_D3_P2.5
D1: LED; LED-5MM
R1, R2, R3, R4, R5: 1k; Resistor_Horizontal_RM10mm
R6: 470
SHIELD1: ARDUINO_SHIELD; ARDUINO SHIELD
SW1, SW2, SW3, SW4, SW5: SW_PUSH; SW_PUSH_SMALL
U1: HC-10; hc10

Connections:
+3V3: C1.1, R5.1, SHIELD1.3V3, U1.12 (3.3V); also elsewhere on the board
+5V: SHIELD1.5V, SW1.1, SW2.1, SW3.1, SW4.1; also elsewhere on the board
/BUTTON_1: R1.2, SHIELD1.2, SW1.2; also elsewhere on the board
/BUTTON_2: R2.2, SHIELD1.3, SW2.2; also elsewhere on the board
/BUTTON_3: R3.2, SHIELD1.4, SW3.2; also elsewhere on the board
/BUTTON_4: R4.2, SHIELD1.5, SW4.2; also elsewhere on the board
/logic_converter/L_RX: U1.2 (UART_RX); also elsewhere on the board
/logic_converter/L_TX: U1.1 (UART_TX); also elsewhere on the board
GND: C1.2, D1.1 (K), R1.1, R2.1, R3.1, R4.1, SHIELD1.GND1, SW5.2, U1.13 (GND1), U1.14 (GND2), U1.21 (GND3), U1.22 (GND4); also elsewhere on the board
unnamed: D1.2 (A), R6.1
unnamed: R5.2, SW5.1, U1.23 (PIO0)
unnamed: R6.2, U1.24 (PIO1)

Parts:
Q1, Q2: BSS138; SOT-23
R7, R8, R9, R10: 10k; Resistor_Horizontal_RM10mm

Connections:
+3V3: Q1.1 (G), Q2.1 (G), R7.1, R8.1; also elsewhere on the board
+5V: R9.1, R10.1; also elsewhere on the board
/logic_converter/H_RX: Q2.3 (D), R10.2; also elsewhere on the board
/logic_converter/H_TX: Q1.3 (D), R9.2; also elsewhere on the board
/logic_converter/L_RX: Q2.2 (S), R8.2; also elsewhere on the board
/logic_converter/L_TX: Q1.2 (S), R7.2; also elsewhere on the board

Board: 4 copper layers, 68.6 x 53.3 mm, 21 parts (0 on the bottom side), 14 nets.

Other parts of the board:
BTSHIELD: ARDUINO_SHIELD; arduino_shield

Their connections:
+3V3: BTSHIELD.3V3; also elsewhere on the board
+5V: BTSHIELD.5V; also elsewhere on the board
/BUTTON_1: BTSHIELD.2; also elsewhere on the board
/BUTTON_2: BTSHIELD.3; also elsewhere on the board
/BUTTON_3: BTSHIELD.4; also elsewhere on the board
/BUTTON_4: BTSHIELD.5; also elsewhere on the board
/logic_converter/H_RX: BTSHIELD.1; also elsewhere on the board
/logic_converter/H_TX: BTSHIELD.0; also elsewhere on the board
GND: BTSHIELD.GND1; also elsewhere on the board

## Commit log

2015-07-24 Initial- bluetooth module schematic and reference diagram created
2015-07-24 Arduino header added
2015-07-30 file dump- needs cleanup
2015-07-30 file dump 2, needs cleanup
2015-07-30 file dump 3
2015-07-30 file dump 4
2015-07-30 removed and renamed files
2015-07-30 shield and schematic w/o missing pieces
2015-07-30 fixed broken components (hopefully)
2015-07-30 removed output files
